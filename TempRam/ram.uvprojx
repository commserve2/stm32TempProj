# Keil uVision project ram.uvprojx, settings and files
target ram (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ram +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER VECT_TAB_RAM
  c include: .\USER;.\FWLIB\inc;.\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x4000
  memory RVCT9: RAM 0x20004000 size 0x1000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c Release_Notes.html core_cm3.h stm32f10x.h system_stm32f10x.h
  group FWLIB
    ./FWLIB/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
    ./FWLIB/inc/: stm32f10x_gpio.h stm32f10x_rcc.h stm32f10x_usart.h
  group USER
    ./USER/: main.c stm32f10x_it.c
  group STARTUP
    ./CMSIS/startup/arm/: startup_stm32f10x_ld.s
  group HEADER
    ./USER/: stm32f10x_it.h
